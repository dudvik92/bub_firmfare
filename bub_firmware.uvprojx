# Keil uVision project bub_firmware.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bub_firmware +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS;.\SPL;.\Main
  asm include: .\CMSIS;.\SPL;.\Main
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: ADC.c cistern.c connection.c CRC16.c handlers.c init.c main.c pump.c thermocouple.c VTimers.c startup_MDR32F9x.s
  group inc
    ./inc/: ADC.h cistern.h connection.h CRC16.h handlers.h init.h main.h pump.h thermocouple.h VTimers.h
  group SPL
    ./SPL/: MDR32F9Qx_adc.c MDR32F9Qx_adc.h MDR32F9Qx_board.h MDR32F9Qx_config.h MDR32F9Qx_lib.h MDR32F9Qx_port.c MDR32F9Qx_port.h MDR32F9Qx_rst_clk.c MDR32F9Qx_rst_clk.h MDR32F9Qx_timer.c MDR32F9Qx_timer.h MDR32F9Qx_uart.c MDR32F9Qx_uart.h
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h MDR32Fx.h system_MDR32F9Qx.c system_MDR32F9Qx.h
software components: CMSIS:CORE 5.4.0
